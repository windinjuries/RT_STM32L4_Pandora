# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, STM32L475xx
  c include: packages\LVGL-v8.3.11\src\extra\libs\sjpg;packages\LVGL-v8.3.11\src\extra\themes;..\..\..\components\drivers\phy;board\CubeMX_Config\Inc;packages\LVGL-v8.3.11\src\extra\others\snapshot;..\libraries\HAL_Drivers;packages\LVGL-v8.3.11\src\extra\libs\qrcode;packages\LVGL-v8.3.11\src\extra;packages\stm32l4_hal_driver-latest\Inc;packages\LVGL-v8.3.11\src\extra\libs\png;packages\LVGL-v8.3.11\env_support\rt-thread;packages\LVGL-v8.3.11\src\extra\others;packages\LVGL-v8.3.11\src\draw\nxp\vglite;packages\LVGL-v8.3.11\src;packages\LVGL-v8.3.11\src\extra\layouts\flex;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\freetype;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\draw\sw;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;packages\LVGL-v8.3.11\src\extra\others\gridnav;..\..\..\libcpu\arm\common;packages\LVGL-v8.3.11\src\draw\renesas;packages\LVGL-v8.3.11\src\extra\layouts\grid;board\ports\lcd;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;packages\LVGL-v8.3.11\src\extra\widgets\calendar;packages\LVGL-v8.3.11\src\extra\widgets\list;..\..\..\components\dfs\dfs_v1\include;..\libraries\HAL_Drivers\drivers\config;packages\LVGL-v8.3.11\src\extra\widgets\span;..\..\..\include;..\..\..\components\libc\posix\io\poll;packages\LVGL-v8.3.11\src\extra\widgets;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\libcpu\arm\cortex-m4;packages\LVGL-v8.3.11\src\extra\widgets\chart;packages\LVGL-v8.3.11\src\extra\others\imgfont;packages\stm32l4_cmsis_driver-latest\Include;packages\LVGL-v8.3.11\src\extra\libs;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;packages\LVGL-v8.3.11\src\extra\layouts;packages\LVGL-v8.3.11\src\extra\libs\rlottie;packages\LVGL-v8.3.11\src\extra\widgets\meter;packages\LVGL-v8.3.11\src\widgets;packages\LVGL-v8.3.11\src\draw\nxp\pxp;.;packages\mpu6xxx-v1.1.1\inc;..\..\..\components\drivers\include;applications;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\CMSIS-Core-latest\Include;packages\LVGL-v8.3.11\src\extra\themes\basic;packages\LVGL-v8.3.11\src\extra\libs\gif;applications\lvgl;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;packages\LVGL-v8.3.11\src\extra\widgets\tabview;packages\LVGL-v8.3.11\src\draw;..\..\..\components\drivers\smp_call;packages\LVGL-v8.3.11\src\extra\widgets\spinbox;packages\Lua-latest\lua-5.3.4;packages\LVGL-v8.3.11\src\extra\widgets\tileview;packages\LVGL-v8.3.11\src\extra\others\ime;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;packages\LVGL-v8.3.11\src\extra\widgets\menu;packages\Lua-latest;..\..\..\components\finsh;packages\LVGL-v8.3.11\src\extra\widgets\led;packages\LVGL-v8.3.11\src\extra\themes\mono;packages\LVGL-v8.3.11\src\extra\widgets\animimg;..\..\..\components\drivers\spi;packages\LVGL-v8.3.11\src\extra\others\monkey;packages\LVGL-v8.3.11\src\extra\libs\bmp;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\themes\default;..\..\..\components\libc\compilers\common\include;packages\LVGL-v8.3.11\src\extra\widgets\win;packages\LVGL-v8.3.11\src\draw\sdl;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;packages\ap3216c-latest;packages\LVGL-v8.3.11\src\extra\others\msg;..\..\..\components\libc\compilers\common\extension;applications\st_driver;..\..\..\components\libc\posix\ipc;board;..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\draw\arm2d;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers;packages\LVGL-v8.3.11\src\extra\widgets\spinner;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;applications\lvgl\demo;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v8.3.11\src\hal;packages\LVGL-v8.3.11\src\core;packages\LVGL-v8.3.11\src\font;packages\LVGL-v8.3.11\src\misc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group ap3216c
    packages/ap3216c-latest/: ap3216c.c
  group Applications
    applications/: data_capture.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_pwm.c drv_soft_i2c.c drv_spi.c drv_tim.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/: board.c
    board/ports/: drv_sensors.c
    board/ports/lcd/: drv_lcd.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_parse.c shell.c msh_file.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c kstring.c rt_vsnprintf_std.c kstdio.c rt_vsscanf.c
  group LCD_SPI
    applications/st_driver/: st_spi.c st7789.c fonts.c st_i2c.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group lua-5.3.4
    packages/Lua-latest/lua-5.3.4/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c lundump.c lutf8lib.c lvm.c lzio.c
    packages/Lua-latest/: lua2rtt.c
  group LVGL
    packages/LVGL-v8.3.11/src/misc/: lv_printf.c lv_style.c lv_anim_timeline.c lv_txt_ap.c lv_timer.c lv_txt.c lv_mem.c lv_templ.c lv_async.c lv_ll.c lv_utils.c lv_math.c lv_area.c lv_style_gen.c lv_lru.c lv_tlsf.c lv_anim.c lv_color.c lv_fs.c lv_gc.c lv_bidi.c lv_log.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: tjpgd.c lv_sjpg.c
    packages/LVGL-v8.3.11/src/font/: lv_font_montserrat_12_subpx.c lv_font_montserrat_24.c lv_font_montserrat_14.c lv_font_montserrat_28_compressed.c lv_font_loader.c lv_font_montserrat_18.c lv_font_montserrat_48.c lv_font_montserrat_28.c lv_font_montserrat_20.c lv_font_montserrat_32.c lv_font_montserrat_38.c lv_font_montserrat_26.c lv_font_unscii_16.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_46.c lv_font_montserrat_10.c lv_font_montserrat_42.c lv_font_montserrat_40.c lv_font_montserrat_36.c lv_font.c lv_font_unscii_8.c lv_font_montserrat_30.c lv_font_montserrat_16.c lv_font_montserrat_34.c lv_font_simsun_16_cjk.c lv_font_fmt_txt.c lv_font_montserrat_44.c lv_font_montserrat_22.c lv_font_montserrat_8.c lv_font_montserrat_12.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_indev.c lv_hal_tick.c lv_hal_disp.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw_img.c lv_draw_layer.c lv_draw_label.c lv_draw_line.c lv_draw_triangle.c lv_img_buf.c lv_draw_mask.c lv_draw_transform.c lv_draw_rect.c lv_img_cache.c lv_draw.c lv_img_decoder.c lv_draw_arc.c
    packages/LVGL-v8.3.11/src/widgets/: lv_label.c lv_line.c lv_btnmatrix.c lv_objx_templ.c lv_canvas.c lv_textarea.c lv_switch.c lv_img.c lv_slider.c lv_roller.c lv_arc.c lv_table.c lv_bar.c lv_dropdown.c lv_btn.c lv_checkbox.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_ra6m3.c lv_gpu_d2_draw_label.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c
    packages/LVGL-v8.3.11/src/core/: lv_event.c lv_group.c lv_obj_style.c lv_obj_pos.c lv_obj_tree.c lv_indev_scroll.c lv_obj_class.c lv_disp.c lv_obj.c lv_refr.c lv_theme.c lv_obj_style_gen.c lv_obj_draw.c lv_indev.c lv_obj_scroll.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl_line.c lv_draw_sdl_stack_blur.c lv_draw_sdl_label.c lv_draw_sdl_texture_cache.c lv_draw_sdl_mask.c lv_draw_sdl_composite.c lv_draw_sdl_layer.c lv_draw_sdl.c lv_draw_sdl_bg.c lv_draw_sdl_polygon.c lv_draw_sdl_img.c lv_draw_sdl_arc.c lv_draw_sdl_rect.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_draw_vglite_blend.c lv_vglite_utils.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_littlefs.c lv_fs_win32.c lv_fs_stdio.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw_dither.c lv_draw_sw_blend.c lv_draw_sw_arc.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_gradient.c lv_draw_sw_letter.c lv_draw_sw_transform.c lv_draw_sw_img.c lv_draw_sw.c lv_draw_sw_layer.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
  group LVGL-demo
    applications/lvgl/demo/: lv_demo.c lv_demo_calendar.c lv_demo_custom.c
    packages/lv_music_demo-v0.3.4/assets/: img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_wave_top.c
    packages/lv_music_demo-v0.3.4/: lv_demo_rtt_music.c lv_demo_rtt_music_list.c lv_demo_rtt_music_main.c
  group LVGL-port
    applications/lvgl/: lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
  group mpu6xxx
    packages/mpu6xxx-v1.1.1/samples/: mpu6xxx_sample.c
    packages/mpu6xxx-v1.1.1/src/: sensor_inven_mpu6xxx.c mpu6xxx.c
  group STM32L4-CMSIS
    packages/stm32l4_cmsis_driver-latest/Source/Templates/: system_stm32l4xx.c
    packages/stm32l4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32l475xx.s
  group STM32L4-HAL
    packages/stm32l4_hal_driver-latest/Src/: stm32l4xx_hal_usart.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cryp.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_crc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_tim.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_cortex.c stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_spi.c stm32l4xx_hal_rng.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_rcc.c
